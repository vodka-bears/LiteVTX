# Keil uVision project LiteVTX.uvproj, settings and files
target LiteVTX (MCS-51)
  device: EFM8BB21F16G-QFN20 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x3FFF) CLOCK(50000000)
  output: LiteVTX +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Startup
    ./: SILABS_STARTUP.A51
  group src
    ./src/: main.c InitDevice.c Interrupts.c delay.c rtc6705.c
